# Keil uVision project DS1307.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1307
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./DS1307/Bai019/Bai019_Ds1307_DongHoSo/: main.c
    ./DS1307/Bai019/Lib/: Delay.c IE74595.c LCD4.c Keypad4x4.c LunarCalendar.c Rtc_Ds1307.c Soft_I2C.c
