# Keil uVision project keypad.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: keypad +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: keypad_interface.c LCD_8_bit.c LCD_8_bit.h
