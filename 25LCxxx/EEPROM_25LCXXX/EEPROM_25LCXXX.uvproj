# Keil uVision project EEPROM_25LCXXX.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EEPROM_25LCXXX +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: DW(16)
  group Source Group 1
    ./: main.c
    ../Lib/: Delay.c
